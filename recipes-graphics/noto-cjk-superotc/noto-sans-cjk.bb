
inherit noto-fonts
inherit noto-cjk

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJK.ttc.zip"
SRC_URI[sha256sum] = "690866416682fc801a4b191866dda5eb809ad36306056a4826d178fa978d8522"

