
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJK.ttc.zip"
SRC_URI[sha256sum] = "ba9db9e4ce3b4b9dcf562e264047c9e989e655aca68809c4f6fc307922b1aef0"

