
inherit noto-fonts
inherit noto-cjk

SRC_URI = "${NOTO_CJK_SANS_SRC_URI_PREFIX}/00_NotoSansCJK.ttc.zip"
SRC_URI[sha256sum] = "a56077736038875f3a5b1e6715b2713a2bd049cc0bf0dfdf645927b070d38bfc"

