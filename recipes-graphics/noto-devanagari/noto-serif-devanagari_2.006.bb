inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE="Serif"
STYLE_LANG="Devanagari"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=e13edde515de034b8074223fadcff8a9"
SRC_URI[sha256sum] = "b823456dfaf6ef8b438eeb906da42effe01927add1e3416ecc86c99c5f1cf098"
