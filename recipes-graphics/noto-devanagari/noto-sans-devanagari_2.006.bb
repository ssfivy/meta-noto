inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE="Sans"
STYLE_LANG="Devanagari"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=e13edde515de034b8074223fadcff8a9"
SRC_URI[sha256sum] = "4c582c103f0a42836338df07148b23a0aa080cce8393ddc4364af87eb22ebd85"
