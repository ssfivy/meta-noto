inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE="Sans"
STYLE_LANG="Hebrew"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=7882143d530dbe277055ce240ee92558"
SRC_URI[sha256sum] = "df0a71814b4e63644cf40fcc4529111b61266b7a2dafbe95068b29a7520cc3cb"
