inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE="Serif"
STYLE_LANG="Hebrew"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=7882143d530dbe277055ce240ee92558"
SRC_URI[sha256sum] = "99523f4f21051495f18cbd5169ed0d1e9b395eefe770fece1844a4a7a00c46da"
