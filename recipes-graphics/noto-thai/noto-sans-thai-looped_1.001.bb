
inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE="Sans"
STYLE_LANG="Thai"
STYLE_NAME="Noto${STYLE_EDGE}${STYLE_LANG}Looped"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=d7c94b25f07127276c3e513f9f9d2b33"
SRC_URI[sha256sum] = "5155c03ce182eaf5e03ffc050a8f38b35eede76b9cc4c91a89fc22834251980d"
