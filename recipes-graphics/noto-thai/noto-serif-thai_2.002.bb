
inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE = "Serif"
STYLE_LANG = "Thai"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=d7c94b25f07127276c3e513f9f9d2b33"
SRC_URI[sha256sum] = "89e3c04bfc54d9a5dd0aec660bf974ad46df38385df7d9397c083482d515049a"
