
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SERIF_SRC_URI_PREFIX}/15_NotoSerifTC.zip"
SRC_URI[sha256sum] = "cadfc894416096a51174e8a350e5cb872f99a8c4b1d36c3990e7a9741e1456ab"

