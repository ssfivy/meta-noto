inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SERIF_SRC_URI_PREFIX}/13_NotoSerifKR.zip"
SRC_URI[sha256sum] = "ac3398873346bc97e00a9652afe791cad6a2df3e5f157c4e7d40ce60b2b88605"
