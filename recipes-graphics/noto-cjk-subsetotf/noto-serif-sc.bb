
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifSC.zip"
SRC_URI[sha256sum] = "00ed5970680a82453619ac5952c5631ea138372bbb0f864d156d91a0fd9c8279"

