
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SERIF_SRC_URI_PREFIX}/12_NotoSerifJP.zip"
SRC_URI[sha256sum] = "53bdd2a6e4eb63bf24f7890e018dddb94366e3555d0814c72b74fbb128f328f0"

