
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SERIF_SRC_URI_PREFIX}/14_NotoSerifSC.zip"
SRC_URI[sha256sum] = "c58cd035ab2adb003510846db9ec80c35b1b97755d329486c3a1e88edfe6e98e"

