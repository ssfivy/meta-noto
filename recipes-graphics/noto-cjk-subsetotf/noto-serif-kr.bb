
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifKR.zip"
SRC_URI[sha256sum] = "a64cbea1a4f8099120b190859d44d0438958861e8c2c6d0afe31a28b120ed7bc"
SRC_URI[sha256sum] = "3c0d276fb05aaefbbca808b4f8c7b1520b4b4e7c0be46296d6e8a5e42f559f5c"

