
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansKR.zip"
SRC_URI[sha256sum] = "5147b755c29f16f82b706b1c7ff7982894fccbebcf99e6c5fb0d48c315604b98"

