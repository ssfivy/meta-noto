
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansJP.zip"
SRC_URI[sha256sum] = "6886c5526628c08f1e21a84f4658ab3daf6d0233de8dc54526ccf9f40bfab18e"

