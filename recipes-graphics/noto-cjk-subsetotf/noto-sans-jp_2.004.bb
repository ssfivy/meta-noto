
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SANS_SRC_URI_PREFIX}/16_NotoSansJP.zip"
SRC_URI[sha256sum] = "2bbdd2c20f30670b39ca735c96d75f1fdabdb348103e43b820cf17701fd22b18"

