
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SANS_SRC_URI_PREFIX}/19_NotoSansTC.zip"
SRC_URI[sha256sum] = "fbbcb216be8056a436c7ec142847f302bb1932d07bdad8b322f4953a389d7cbc"

