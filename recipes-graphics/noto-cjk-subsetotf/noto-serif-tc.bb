
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifTC.zip"
SRC_URI[sha256sum] = "c33e04199f6d69056a6de0ebc5522dbe36e02f145208c71c9a4c803841151ad2"

