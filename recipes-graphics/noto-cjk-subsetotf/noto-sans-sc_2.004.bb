
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SANS_SRC_URI_PREFIX}/18_NotoSansSC.zip"
SRC_URI[sha256sum] = "4d107c09ada479d3e48b6e78c83835773cbd9214bf6e12cdb7b60f8e068292ec"

