
inherit noto-fonts
inherit noto-cjk

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJK-Bold.ttc.zip"
SRC_URI[sha256sum] = "3cd895bce6765903b2eefcd90eea6ed372364e66d5b896ea3a594bd3e737eba0"

