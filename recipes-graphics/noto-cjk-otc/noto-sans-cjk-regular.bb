
inherit noto-fonts
inherit noto-cjk

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJK-Regular.ttc.zip"
SRC_URI[sha256sum] = "32d03afb0b1109fa75a96f89dfc118015283a5343f2216ee4b3757c19992f75d"

