
inherit noto-fonts
inherit noto-cjk

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJK-ExtraLight.ttc.zip"
SRC_URI[sha256sum] = "df424dd924ff435fa2c806e637e3fdfbf683b0829ca10f89586b1f9e70282ef5"

