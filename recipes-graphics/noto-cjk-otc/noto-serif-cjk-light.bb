
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJK-Light.ttc.zip"
SRC_URI[sha256sum] = "4638c1c7a80b4e57239b0d938f7b62a01a41a67cffa49b92de151517f7f03fc3"

