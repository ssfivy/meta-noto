
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJK-Regular.ttc.zip"
SRC_URI[sha256sum] = "4c03e0457894c7e2d72bdd96301741803480693853741d54bb804bdc62579658"

