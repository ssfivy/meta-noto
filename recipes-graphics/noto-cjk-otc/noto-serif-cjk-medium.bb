
inherit noto-fonts
inherit noto-cjk

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJK-Medium.ttc.zip"
SRC_URI[sha256sum] = "2514347d151d1a3a7c2ab9b2c4be47dc145a28b8db9c3c320292cef864b6df9b"

