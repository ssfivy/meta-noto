
inherit noto-fonts
inherit noto-cjk

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJK-Black.ttc.zip"
SRC_URI[sha256sum] = "9afe986d8aad1e1ff36848cdd0b78ecffc4023cce3092ec92848859dce320075"

