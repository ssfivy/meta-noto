
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJK-Light.ttc.zip"
SRC_URI[sha256sum] = "24cedc1a484f30f09f4dc8f5faf6f8620e377782eb57e4d1f3d98f7f22e79526"

