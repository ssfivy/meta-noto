
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJK-DemiLight.ttc.zip"
SRC_URI[sha256sum] = "74eea3d4d0837bdc42f0ad11b9bf764b9ba5044778a641c8e6483941eff3b37e"

