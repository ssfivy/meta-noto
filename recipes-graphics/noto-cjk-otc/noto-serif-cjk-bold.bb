
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJK-Bold.ttc.zip"
SRC_URI[sha256sum] = "97b5322b887eac18c2a7f3e8eb2ddec476743ba6c8992977bbb20bd5a342781e"

