
inherit noto-fonts
inherit noto-cjk

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJK-Thin.ttc.zip"
SRC_URI[sha256sum] = "cf622a73cab6dc0e071f2ec04e572b2fa018efc003a6505575cf29241343ccfb"

