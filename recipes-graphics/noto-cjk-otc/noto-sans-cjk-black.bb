
inherit noto-fonts
inherit noto-cjk

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJK-Black.ttc.zip"
SRC_URI[sha256sum] = "be2897aca58f8fcab3bad6934875941f4310b6310707ead867efcd0460415fea"

