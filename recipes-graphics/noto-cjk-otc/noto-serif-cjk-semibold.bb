
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJK-SemiBold.ttc.zip"
SRC_URI[sha256sum] = "32847dd54741595c2fc651a045e80f82185635768b69aea31058bbb94bd15efa"

