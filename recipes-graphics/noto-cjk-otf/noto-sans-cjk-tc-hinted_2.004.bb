
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SANS_SRC_URI_PREFIX}/09_NotoSansCJKtc.zip"
SRC_URI[sha256sum] = "8ea0d6feb8e092c250710cdc75c138090832ddaa98d8ccb37cd89b03b72c331b"

