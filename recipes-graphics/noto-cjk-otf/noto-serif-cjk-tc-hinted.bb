
inherit noto-fonts
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJKtc-hinted.zip"
SRC_URI[sha256sum] = "6e567713e7da72f3582c8cc1ac017167c1312aa95bbb182a6143fe2b12bd58ec"

