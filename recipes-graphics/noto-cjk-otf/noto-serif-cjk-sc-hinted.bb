
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SERIF_SRC_URI_PREFIX}/09_NotoSerifCJKsc.zip"
SRC_URI[sha256sum] = "4bcdbff95cedfb6a4c0640403f0de8b69480d869331c24c8eff91f7bb834df04"

