
inherit noto-fonts
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJKsc-hinted.zip"
SRC_URI[sha256sum] = "bf1fb4edd4c268c45f7367d976a586ce2e79ba6166e09340f5e70d748c26f41c"

