
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJKtc-hinted.zip"
SRC_URI[sha256sum] = "74e6e9144f1e1a160f2eab7599971989e3da9c998d7ceda0ebcfda86dd2997b5"

