
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SERIF_SRC_URI_PREFIX}/08_NotoSerifCJKkr.zip"
SRC_URI[sha256sum] = "2132d84616ea55b2b6073bd7b3da5ccd90e59e61fdeab681107d33ab099be367"

