
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SERIF_SRC_URI_PREFIX}/07_NotoSerifCJKjp.zip"
SRC_URI[sha256sum] = "d7e956584f1e9417a0a72de22bfc33103d7dea78c9f84e5876920eb35ef40a13"

