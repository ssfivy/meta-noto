
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SANS_SRC_URI_PREFIX}/06_NotoSansCJKjp.zip"
SRC_URI[sha256sum] = "bf5b26feb83ee02533d4eb4a127bd90ed9d42bdd7ca7cb6e4030b2f21ef55cc5"

