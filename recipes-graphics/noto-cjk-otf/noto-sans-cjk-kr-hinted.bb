
inherit noto-fonts
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansCJKkr-hinted.zip"
SRC_URI[sha256sum] = "1412d5af7d636a72d744914bc7cf34eb05e08955262f05b00bc13d5c7f50f57a"

