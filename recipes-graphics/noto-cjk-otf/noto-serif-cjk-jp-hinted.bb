
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJKjp-hinted.zip"
SRC_URI[sha256sum] = "ca323a0ab974a49063884a404f233d93e0dbb51b21a5943091d9e5d5922a4e0a"

