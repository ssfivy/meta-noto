
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifCJKkr-hinted.zip"
SRC_URI[sha256sum] = "a64cbea1a4f8099120b190859d44d0438958861e8c2c6d0afe31a28b120ed7bc"

