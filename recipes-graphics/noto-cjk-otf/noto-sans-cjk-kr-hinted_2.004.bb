
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SANS_SRC_URI_PREFIX}/07_NotoSansCJKkr.zip"
SRC_URI[sha256sum] = "e26fcf98e75176d24984875377ab921dbb46055b88ed4a39454d91d6146c5654"

