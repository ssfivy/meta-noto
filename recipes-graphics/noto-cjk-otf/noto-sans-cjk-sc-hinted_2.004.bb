
inherit noto-fonts
inherit noto-cjk
inherit noto-cjk-styles

SRC_URI = "${NOTO_CJK_SANS_SRC_URI_PREFIX}/08_NotoSansCJKsc.zip"
SRC_URI[sha256sum] = "a927e56f53bd6c3b920bc139c0b94aa36c7d9ad0cf009b159437a1a003581140"

