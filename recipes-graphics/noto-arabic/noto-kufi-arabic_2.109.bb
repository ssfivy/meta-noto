inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE = "Kufi"
STYLE_LANG = "Arabic"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=f319a2b8bcf8e25835957d7835f177b0"
SRC_URI[sha256sum] = "1b6880e4b8df09c3b9e246d6084bfd94bf32a0ffff60cf2dcffd3622d0e2d79f"
