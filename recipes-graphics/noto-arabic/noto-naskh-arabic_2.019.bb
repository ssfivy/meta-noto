inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE = "Naskh"
STYLE_LANG = "Arabic"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=f319a2b8bcf8e25835957d7835f177b0"
SRC_URI[sha256sum] = "7a509e10c9c8d21f384a26807ef2f5fbbecec46fdb8626c5441bed6d894edb81"
