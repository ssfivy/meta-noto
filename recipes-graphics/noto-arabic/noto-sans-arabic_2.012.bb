inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE = "Sans"
STYLE_LANG = "Arabic"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=f319a2b8bcf8e25835957d7835f177b0"
SRC_URI[sha256sum] = "65bceb5106ca17e8e0b4660bacec4d362afd56e0251e71fedf83f76dfe9f4abe"
