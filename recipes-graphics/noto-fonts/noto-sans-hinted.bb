
inherit noto-fonts
inherit noto-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSans-hinted.zip"
SRC_URI[sha256sum] = "02e5f834c526f815f3b9f90f98e2b5b09f17cec107cc751c3b58fc3a2c0b2942"

