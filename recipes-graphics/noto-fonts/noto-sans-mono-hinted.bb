inherit noto-fonts
inherit noto-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSansMono-hinted.zip"
SRC_URI[sha256sum] = "08bc1d07e546ce79d8b8abd6812c86d77fba5d1f4b54529390e8a57d65827b76"
