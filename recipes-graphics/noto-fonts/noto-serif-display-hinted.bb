
inherit noto-fonts
inherit noto-styles

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoSerifDisplay-hinted.zip"
SRC_URI[sha256sum] = "769b74543460f3ed3b2cf905c12afbc2a741b47b178be77cde935de417914d88"

