
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoColorEmoji-unhinted.zip"
SRC_URI[sha256sum] = "d7983299f53742592f61539607c5d9528bcc83639f9a99df94a22c0df4890355"

