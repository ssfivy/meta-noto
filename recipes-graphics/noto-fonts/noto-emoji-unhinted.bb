
inherit noto-fonts

SRC_URI = "${NOTO_SRC_URI_PREFIX}/NotoEmoji-unhinted.zip"
SRC_URI[sha256sum] = "61f6a71a8e84b57f52b2255ee8bb6e0bf14515ff7c453485f11f497d9cdc5d78"

