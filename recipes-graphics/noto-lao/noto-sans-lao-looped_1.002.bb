inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE = "Sans"
STYLE_LANG = "Lao"
STYLE_NAME = "Noto${STYLE_EDGE}${STYLE_LANG}Looped"

SRC_URI[sha256sum] = "8006a78e1a208838d605bcc3264f5e7e54eb9d5ccf330cfed42d17b257391a50"
