inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE = "Sans"
STYLE_LANG = "Lao"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=667099facaed0b90e3145542745c30ef"
SRC_URI[sha256sum] = "5a87c31b1a40ef8147c1e84437e5f0ceba2d4dbbfc0b56a65821ad29870da8c0"
