inherit noto-fonts-hinted
inherit noto-styles

STYLE_EDGE = "Serif"
STYLE_LANG = "Lao"

LIC_FILES_CHKSUM = "file://OFL.txt;md5=667099facaed0b90e3145542745c30ef"
SRC_URI[sha256sum] = "e96a303d3347790b0ef3db274971a989a736ce766ec9ea1bea0e1458568a80b2"
